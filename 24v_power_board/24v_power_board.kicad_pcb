# Repository oosan1/Tsuyama2026_electronics_clean (continued)

## KiCad design Nucleo-F446RE_control_board/Nucleo-F446RE_control_board.kicad_pcb

Parts:
C1: 47u; CP_Radial_D6.3mm_P2.50mm
C2, C8, C9, C10: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C3, C4, C5, C6, C7: R兼用; C_Disc_D3.8mm_W2.6mm_P2.50mm; not fitted
D1: LED; LED_D5.0mm
J1, J8, J16: Conn_01x02_Pin; DF1E-2P-2.5DS
J2, J3, J4, J5, J6: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical; not fitted
J7, J15: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J9, J13, J14: Conn_01x04_Pin; DF1E-4P-2.5DS
J10, J11, J12: Conn_01x03_Pin; S03B-PASK-2
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2, R3, R4, R5, R6: R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
R7, R8, R9, R10, R11: 0; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
R12, R15: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R13, R14: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
U1: F446RE_mainPIN
U2, U3: MCP2562-E-P; DIP-8_W7.62mm

Connections:
+3.3V: C8.2, C10.2, J2.2, J3.2, J4.2, J5.2, J6.2, J9.3, J13.3, R2.2, R3.2, R4.2, R5.2, R6.2, R13.1, R14.1, U1.CN7_16 (CN7_+3V3), U2.5 (Vio), U3.5 (Vio)
+5V: C1.1, C2.1, C9.1, J1.2, J14.3, R1.1, U1.CN7_6 (E5V), U2.3 (VDD), U3.3 (VDD)
/CAN1+: J7.2, J8.1, U2.7 (CANH)
/CAN1-: J8.2, R12.2, U2.6 (CANL)
/CAN1_RX: U1.CN10_14 (PA11), U2.4 (RXD)
/CAN1_TX: U1.CN10_12 (PA12), U2.1 (TXD)
/CAN2+: J15.2, J16.1, U3.7 (CANH)
/CAN2-: J16.2, R15.2, U3.6 (CANL)
/CAN2_RX: U1.CN10_16 (PB12), U3.4 (RXD)
/CAN2_TX: U1.CN10_30 (PB13), U3.1 (TXD)
/I2C_SCL: J9.2, R14.2, U1.CN10_3 (PB8)
/I2C_SDA: J9.4, R13.2, U1.CN10_5 (PB9)
/PA4: R7.1, U1.CN7_32 (PA4)
/PA9: J14.2, U1.CN10_21 (PA9)
/PA10: J14.4, U1.CN10_33 (PA10)
/PB0: R8.1, U1.CN7_34 (PB0)
/PB14: J13.2, U1.CN10_28 (PB14)
/PB15: J13.4, U1.CN10_26 (PB15)
/PC2: R9.1, U1.CN7_35 (PC2)
/PC3: R10.1, U1.CN7_37 (PC3)
/PC10: R11.1, U1.CN7_1 (PC10)
/PWM1: J10.3, U1.CN10_4 (PC6)
/PWM2: J10.1, U1.CN10_19 (PC7)
/PWM3: J11.3, U1.CN10_2 (PC8)
/PWM4: J11.1, U1.CN10_1 (PC9)
/PWM5: J12.3, U1.CN7_28 (PA0)
/PWM6: J12.1, U1.CN7_30 (PA1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.2, C10.1, D1.1 (K), J1.1, J2.3, J3.3, J4.3, J5.3, J6.3, J9.1, J10.2, J11.2, J12.2, J13.1, J14.1, U1.CN7_8 (CN7_GND), U1.CN7_19 (CN7_GND__1), U1.CN7_20 (CN7_GND__2), U1.CN7_22 (CN7_GND__3), U1.CN10_9 (CN10_GND), U1.CN10_20 (CN10_GND__1), U2.2 (VSS), U2.8 (STBY), U3.2 (VSS), U3.8 (STBY)
unnamed: D1.2 (A), R1.2
unnamed: C3.1, J2.1, R2.1, R7.2
unnamed: C4.1, J3.1, R3.1, R8.2
unnamed: C5.1, J4.1, R4.1, R9.2
unnamed: C6.1, J5.1, R5.1, R10.2
unnamed: C7.1, J6.1, R6.1, R11.2
unnamed: J7.1, R12.1
unnamed: J15.1, R15.1

Notes on the sheet:
プルアップ プルダウン RCフィルタ に対応
5V電源LED
I2C
PWM
シリアルサーボ
CAN通信
空圧用
予備GPIO

Board: 2 copper layers, 100.0 x 90.0 mm, 45 parts (0 on the bottom side), 36 nets.

## KiCad design servo_control_board/servo_control_board.kicad_pcb

Board: 2 copper layers, 85.0 x 35.0 mm, 34 parts (0 on the bottom side), 15 nets.

Parts:
C1, C2, C3, C4: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C5: 470u; CP_Radial_D10.0mm_P5.00mm
J1, J2: Conn_01x03_Pin; S03B-PASK-2
J3, J4, J5, J6: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Horizontal
J7: Conn_01x02_Pin; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
R1, R2, R3, R4: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5, R6, R7, R8: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
TP1, TP2, TP4, TP5, TP6, TP7, TP8, TP9: TestPoint_Probe; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP3, TP10: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1, U2, U3, U4: H11L1M; DIP-6_W7.62mm_LongPads

Connections:
+SERVO: C1.2, C2.2, C3.2, C4.2, C5.1, J3.2, J4.2, J5.2, J6.2, J7.2, R5.1, R6.1, R7.1, R8.1, U1.6 (VCC), U2.6 (VCC), U3.6 (VCC), U4.6 (VCC)
GND: J1.2, J2.2, TP3.1 (1_1), U1.2, U2.2, U3.2, U4.2
GNDPWR: C1.1, C2.1, C3.1, C4.1, C5.2, J3.1, J4.1, J5.1, J6.1, J7.1, TP10.1 (1_1), U1.5 (GND), U2.5 (GND), U3.5 (GND), U4.5 (GND)
unnamed: J1.1, R1.1, TP1.1 (1_1)
unnamed: J1.3, R3.1, TP4.1 (1_1)
unnamed: J2.1, R2.1, TP2.1 (1_1)
unnamed: J2.3, R4.1, TP5.1 (1_1)
unnamed: J3.3, R5.2, TP6.1 (1_1), U1.4
unnamed: J4.3, R6.2, TP7.1 (1_1), U2.4
unnamed: J5.3, R7.2, TP8.1 (1_1), U3.4
unnamed: J6.3, R8.2, TP9.1 (1_1), U4.4
unnamed: R1.2, U2.1
unnamed: R2.2, U4.1
unnamed: R3.2, U1.1
unnamed: R4.2, U3.1
