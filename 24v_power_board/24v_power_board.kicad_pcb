# Repository oosan1/Tsuyama2026_electronics_clean

File README.md:

以下の回路基板を設計するにあたって用いたリポジトリから，公開できないデータを削除したもの．
[Tsuyama2026_electronics](https://github.com/okarobo-tsuyama2026/Tsuyama2026_electronics_public)

コミットログや設計途中の回路基板を閲覧できる．

## KiCad design 24v_power_board/24v_power_board.kicad_pcb

Parts:
C1, C2, C3: 0.1u; C_0603_1608Metric
C4: 10u; C_Disc_D6.0mm_W4.4mm_P5.00mm
D1, D5: SMBJ30CA; D_SMB_TVS
D2, D6, D7: LED; LED_D5.0mm
D3: SM340A; D_SMA_Handsoldering
D4: 1N4148; D_DO-34_SOD68_P2.54mm_Vertical_CathodeUp
DZ1: BZX55C9V1; D_DO-35_SOD27_P2.54mm_Vertical_AnodeUp
F1: 5; FUC-03A_20mm
F2: 30; 3557-15_KEY
F3: MF-RX065; Fuse_BelFuse_0ZRE0016FF_L9.9mm_W3.8mm
J1: Conn_01x02_Pin; DF1EC-2P-2.5DSA
J2: Conn_01x02_Pin; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J3, J4: Conn_01x02_Pin; DF1E-2P-2.5DS
J5, J6, J7, J8, J9, J10, J11, J12, J13, J14: Conn_01x02_Socket; AMASS_XT30U-F_1x02_P5.0mm_Vertical
J15: Conn_01x04_Pin; DF1EC-4P-2.5DSA
K1: A31CCQ24VDC1D; DZ85AB5PCB_ForA31CCQ24VDC1D
NT1: NetTie_2; NetTie-2_SMD_Pad2.0mm
Q1: 2SA1015; TO-92_Inline
Q2: BS170; TO-92_Inline
R1: 1m; HoYLR2512E; MPN C5375452
R2, R12, R13: 7.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3: 100; R_0603_1608Metric
R4, R5: 10; R_0603_1608Metric
R6: 10; R_Axial_Power_L25.0mm_W9.0mm_P7.62mm_Vertical
R7, R8: 47k; R_0603_1608Metric
R9: 100k; R_0603_1608Metric
R10: 220k; R_0603_1608Metric
R11: 47; R_0603_1608Metric
R14, R15: 4.7k; R_0603_1608Metric
RV1: 1000k; GF063P
TP1, TP3, TP4: TestPoint_Probe; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP2: TestPoint_2Pole; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
U1: INA226; TSSOP-10_3x3mm_P0.5mm

Connections:
+3.3V: C1.1, J15.3, R14.1, R15.1, U1.6 (VS)
+24V_CTRL: F1.1, J10.2, J11.2, J12.2, J13.2, J14.2, R13.1, TP4.1 (1_1)
+24V_DRV: D5.2 (A), J5.2, J6.2, J7.2, J8.2, J9.2, K1.30, R6.2, R12.1, TP3.1 (1_1)
/I2C_SCL: J15.2, R15.2, U1.5 (SCL)
/I2C_SDA: J15.4, R14.2, U1.4 (SDA)
GND: C1.2, C2.2, D7.1 (K), J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, NT1.2, TP2.1, TP2.2, U1.1 (A1), U1.2 (A0), U1.7 (GND)
GNDPWR: C4.2, D1.1 (K), D2.1 (K), D5.1 (K), D6.1 (K), DZ1.2 (A), J1.1, J2.1, J5.1, J6.1, J7.1, J8.1, J9.1, NT1.1, Q2.3 (S), R11.2
unnamed: D1.2 (A), J2.2, R1.4, R2.1
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), F3.2
unnamed: D3.1 (K), R6.1
unnamed: C4.1, D4.2 (A), DZ1.1 (K), J4.1, Q2.2 (G), R10.2, RV1.2, RV1.3, TP1.1 (1_1)
unnamed: D4.1 (K), F3.1, J3.2, K1.86, Q1.1 (E), R7.1, R9.1
unnamed: D6.2 (A), R12.2
unnamed: D7.2 (A), R13.2
unnamed: F1.2, F2.1, R1.1, R3.2
unnamed: F2.2, J1.2, J3.1, K1.87
unnamed: J4.2, R11.1
unnamed: Q1.3 (B), R7.2, R8.1
unnamed: Q1.2 (C), R10.1
unnamed: K1.85, Q2.1 (D), R8.2
unnamed: R1.2, R5.1
unnamed: R1.3, R4.2
unnamed: R9.2, RV1.1
unnamed: C2.1, R3.1, U1.8 (Vbus)
unnamed: C3.2, R4.1, U1.10 (Vin+)
unnamed: C3.1, R5.2, U1.9 (Vin-)

Notes on the sheet:
制御用電源
駆動用電源
バッテリーLED
非常停止スイッチ NO
なるべくネットタイの近くに配置
駆動電源LED
24Vフロントエンド
電圧モニタ用
プリチャージ用
可変抵抗による調整範囲 0.1秒〜1.2秒
非常停止スイッチ NC
Address: 0
フットプリント要チェック
制御電源LED

Board: 2 copper layers, 100.0 x 60.0 mm, 55 parts (18 on the bottom side), 27 nets.

## KiCad design Nucleo-F303K8_control_board/Nucleo-F303K8_control_board.kicad_pcb

Parts:
C1: 47u; CP_Radial_D6.3mm_P2.50mm
C2, C5: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C3, C4: R兼用; C_Disc_D3.8mm_W2.6mm_P2.50mm; not fitted
D1: LED; LED_D5.0mm
J1, J5: Conn_01x02_Pin; DF1E-2P-2.5DS
J2, J3: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical; not fitted
J4: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J6, J10, J11: Conn_01x04_Pin; DF1E-4P-2.5DS
J7, J8, J9: Conn_01x03_Pin; S03B-PASK-2
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2, R3: R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
R4, R5: 0; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
R6: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R7, R8: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
U1: NUCLEO-F303K8; PARTREV 5
U2: MCP2562-E-P; DIP-8_W7.62mm

Connections:
/CAN1+: J4.2, J5.1, U2.7 (CANH)
/CAN1-: J5.2, R6.2, U2.6 (CANL)
/CAN1_RX: U1.3_13 (PA11), U2.4 (RXD)
/CAN1_TX: U1.3_5 (PA12), U2.1 (TXD)
/I2C_SCL: J6.2, R8.2, U1.3_8 (PB6)
/I2C_SDA: J6.4, R7.2, U1.3_7 (PB7)
/PA3: R4.1, U1.4_10 (PA3)
/PA4: R5.1, U1.4_9 (PA4)
/PA5: J10.2, U1.4_8 (PA5)
/PA6: J10.4, U1.4_7 (PA6)
/PA9: J11.2, U1.3_1 (PA9)
/PA10: J11.4, U1.3_2 (PA10)
/PWM1: J7.3, U1.3_15 (PB4)
/PWM2: J7.1, U1.3_14 (PB5)
/PWM3: J8.3, U1.3_6 (PB0)
/PWM4: J8.1, U1.3_9 (PB1)
/PWM5: J9.3, U1.4_12 (PA0)
/PWM6: J9.1, U1.4_11 (PA1)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, D1.1 (K), J1.1, J2.3, J3.3, J6.1, J7.2, J8.2, J9.2, J10.1, J11.1, U1.3_4 (GND_1), U1.4_2 (GND_2), U2.2 (VSS), U2.8 (STBY)
unnamed: D1.2 (A), R1.2
unnamed: C3.1, J2.1, R2.1, R4.2
unnamed: C4.1, J3.1, R3.1, R5.2
unnamed: J4.1, R6.1

Notes on the sheet:
シリアルサーボ
5V電源LED
プルアップ プルダウン RCフィルタ に対応
PWM
CAN通信
I2C
予備GPIO
空圧用

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
Board: 2 copper layers, 55.0 x 70.0 mm, 27 parts (0 on the bottom side), 25 nets.

## KiCad design ESP32-DevKitC_control_board/ESP32-DevKitC_control_board.kicad_pcb

Board: 2 copper layers, 85.0 x 60.0 mm, 33 parts (0 on the bottom side), 24 nets.

Parts:
C1, C3: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C2: 47u; CP_Radial_D6.3mm_P2.50mm
C4, C5, C6, C7: R兼用; C_Disc_D3.8mm_W2.6mm_P2.50mm
D1: LED; LED_D5.0mm
J1, J2: Conn_01x03_Pin; S03B-PASK-2
J3, J5, J7: Conn_01x02_Pin; DF1E-2P-2.5DS
J4: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J6: Conn_01x04_Pin; DF1E-4P-2.5DS
J8, J9, J10, J11: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3, R4: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5, R6, R7, R8: R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R9, R10, R11, R12: 0; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
U1: MCP2562-E-P; DIP-8_W7.62mm
U2: ESP32-DevKitC

Connections:
+3.3V: C3.2, J6.3, J7.1, J8.2, J9.2, J10.2, J11.2, R3.1, R4.1, R5.2, R6.2, R7.2, R8.2, U1.5 (Vio), U2.1 (3V3)
+5V: C1.1, C2.1, J3.2, R1.1, U1.3 (VDD), U2.19 (5V)
/CAN1+: J4.2, J5.1, U1.7 (CANH)
/CAN1-: J5.2, R2.2, U1.6 (CANL)
/CAN_RX: U1.4 (RXD), U2.30 (GPIO18)
/CAN_TX: U1.1 (TXD), U2.31 (GPIO19)
/GPIO4: J7.2, U2.26 (ADC2_CH0/GPIO4)
/GPIO13: R9.1, U2.15 (MTCK/GPIO13/ADC2_CH4)
/GPIO23: R10.1, U2.37 (GPIO23)
/GPIO32: R12.1, U2.7 (32K_XP/GPIO32/ADC1_CH4)
/GPIO33: R11.1, U2.8 (32K_XN/GPIO33/ADC1_CH5)
/I2C_SCL: J6.2, R4.2, U2.36 (GPIO22)
/I2C_SDA: J6.4, R3.2, U2.33 (GPIO21)
/PWM1: J1.3, U2.12 (MTMS/GPIO14/ADC2_CH6)
/PWM2: J1.1, U2.11 (ADC2_CH7/GPIO27)
/PWM3: J2.3, U2.9 (DAC_1/ADC2_CH8/GPIO25)
/PWM4: J2.1, U2.10 (DAC_2/ADC2_CH9/GPIO26)
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, D1.1 (K), J1.2, J2.2, J3.1, J6.1, J8.3, J9.3, J10.3, J11.3, U1.2 (VSS), U1.8 (STBY), U2.14 (GND), U2.32 (GND), U2.38 (GND)
unnamed: D1.2 (A), R1.2
unnamed: J4.1, R2.1
unnamed: C4.1, J8.1, R5.1, R9.2
unnamed: C5.1, J9.1, R6.1, R10.2
unnamed: C6.1, J10.1, R7.1, R11.2
unnamed: C7.1, J11.1, R8.1, R12.2

## KiCad design DCmotor_control_board/DCmotor_control_board.kicad_pcb

Board: 2 copper layers, 45.0 x 55.0 mm, 26 parts (2 on the bottom side), 22 nets.

Parts:
C1: 0.33u; C_Disc_D3.8mm_W2.6mm_P2.50mm
C2: 330u; CP_Radial_D10.0mm_P5.00mm
C3, C4, C5, C6, C7, C8: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
D1: LED; LED_D5.0mm
J1: Conn_01x02_Pin; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2, J3: Conn_01x04_Pin; DF1E-4P-2.5DS
J4, J5: Conn_01x02_Pin; DF1E-2P-2.5DS
R1, R2, R4, R5: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
U1: L7805CV; TO-220-3_Vertical
U2, U3, U5, U6: TLP2745; SO-6L_10x3.84mm_P1.27mm
U4, U7: TB67H450FNG_EL; P-HSOP8-0405-1p27-002_TOS-L

Connections:
+5V: C4.2, C5.2, C6.2, C7.2, C8.2, R3.1, U1.3 (OUT), U2.6 (VDD), U3.6 (VDD), U4.4 (VREF), U5.6 (VDD), U6.6 (VDD), U7.4 (VREF)
+MOTOR: C1.2, C2.1, C3.2, J1.2, U1.1 (IN), U4.5 (VM), U7.5 (VM)
/IN1_1: U2.5 (VO), U4.3 (IN1)
/IN1_2: U3.5 (VO), U4.2 (IN2)
/IN2_1: U5.5 (VO), U7.3 (IN1)
/IN2_2: U6.5 (VO), U7.2 (IN2)
/SIG_IN1: J2.2, R1.1
/SIG_IN2: J2.4, R2.1
/SIG_IN3: J3.2, R4.1
/SIG_IN4: J3.4, R5.1
GND1: J2.1, U2.3 (K), U3.3 (K)
GND2: J3.1, U5.3 (K), U6.3 (K)
GNDPWR: C1.1, C2.2, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, D1.1 (K), J1.1, U1.2, U2.4 (GND), U3.4 (GND), U4.1 (GND), U4.7 (RS), U4.9 (GND), U5.4 (GND), U6.4 (GND), U7.1 (GND), U7.7 (RS), U7.9 (GND)
unnamed: D1.2 (A), R3.2
unnamed: J4.1, U4.6 (OUT1)
unnamed: J4.2, U4.8 (OUT2)
unnamed: J5.1, U7.6 (OUT1)
unnamed: J5.2, U7.8 (OUT2)
unnamed: R1.2, U2.1 (A)
unnamed: R2.2, U3.1 (A)
unnamed: R4.2, U5.1 (A)
unnamed: R5.2, U6.1 (A)

## KiCad design micon_power_board/micon_power_board.kicad_pcb

Parts:
C1: 100u; CP_Radial_D8.0mm_P3.50mm
C2: 10u; C_Disc_D6.0mm_W4.4mm_P5.00mm
C3: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C4, C5: 2.2u; C_Disc_D6.0mm_W4.4mm_P5.00mm
D1: SBM1060LSS; D_DO-201AD_P3.81mm_Vertical_CathodeUp
D2, D3: LED; LED_D5.0mm
J1, J2, J3, J4, J5: Conn_01x02_Pin; DF1E-2P-2.5DS
J6: Conn_01x02_Pin; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J7: Conn_01x02_Socket; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
R1: 7.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
TP1, TP3: TestPoint_Probe; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP2: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: M78AR05-1

Connections:
GND: C1.2, C2.2, C3.1, C4.2, C5.2, D2.1 (K), D3.1 (K), J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, TP2.1 (1_1), U1.2 (GND)
unnamed: D1.2 (A), J6.2, J7.2
unnamed: C1.1, C2.1, C3.2, D1.1 (K), R1.1, TP3.1 (1_1), U1.1 (VI)
unnamed: D2.2 (A), R1.2
unnamed: D3.2 (A), R2.2
unnamed: C4.1, C5.1, J1.2, J2.2, J3.2, J4.2, J5.2, R2.1, TP1.1 (1_1), U1.3 (VO)

Notes on the sheet:
2.2uFが余っているため 4.7uF一つでも良い
電源LED
5V電源LED

Board: 2 copper layers, 55.0 x 45.0 mm, 21 parts (0 on the bottom side), 6 nets.

## KiCad design serial_servo_control_board/serial_servo_control_board.kicad_pcb

Parts:
C1: 0.33u; C_Disc_D3.8mm_W2.6mm_P2.50mm
C3: 2.2u; C_Disc_D6.0mm_W4.4mm_P5.00mm
C5: 470u; CP_Radial_D10.0mm_P5.00mm
C6, C7: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
D4, D5: 1N4148; D_DO-34_SOD68_P2.54mm_Vertical_CathodeUp
J1: Conn_01x04_Pin; DF1E-4P-2.5DS
J2: Conn_01x02_Pin; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J3: Conn_01x03_Pin; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
Q1, Q2: BSS138; SOT-23
R1, R2, R4: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
TP1, TP2: TestPoint_Probe; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP3, TP4: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: NJM2884U2-05; SOT-89-5
U2, U3: TLP2745; SO-6L_10x3.84mm_P1.27mm

Connections:
+5V_CTRL: C6.2, J1.3, R1.1, U3.6 (VDD)
+5V_PWR: C3.1, C7.2, R2.1, R4.2, U1.4 (VOUT), U2.6 (VDD)
+SERVO: C1.2, C5.1, J2.2, J3.2, U1.1 (CTRL), U1.5 (VIN)
/RX: J1.4, TP2.1 (1_1), U3.5 (VO)
/TX: J1.2, U2.3 (K)
/signal: J3.3, Q1.1 (G), Q2.3 (D), R2.2, TP1.1 (1_1)
GND: C6.1, J1.1, TP3.1 (1_1), U3.4 (GND)
GNDPWR: C1.1, C3.2, C5.2, C7.1, J2.1, J3.1, Q1.2 (S), Q2.2 (S), R5.1, TP4.1 (1_1), U1.2 (GND), U2.4 (GND)
unnamed: D4.2 (A), R1.2
unnamed: D4.1 (K), D5.2 (A)
unnamed: D5.1 (K), U2.1 (A)
unnamed: Q1.3 (D), U3.3 (K)
unnamed: Q2.1 (G), R5.2, U2.5 (VO)
unnamed: R4.1, U3.1 (A)

Notes on the sheet:
6.0V

Board: 2 copper layers, 35.0 x 50.0 mm, 23 parts (1 on the bottom side), 14 nets.
